# Keil uVision project project.uvprojx, settings and files
target first (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project
  c flags: OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\ST_Code;..\Library\inc;..\Mycode;..\FreeRTOS\include;..\FreeRTOS\port\RVDS\ARM_CM4F;..\Mycode\eMPL;..\Mycode\MPU6050
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group STcode
    ../ST_Code/: system_stm32f4xx.c startup_stm32f40_41xxx.s
  group Mycode
    ../Mycode/: main.c led.c key.c delay.c timer.c usart.c hcsr04.c dht11.c light.c at24c02.c oled.c spi.c w25q128.c max30102.c rtc.c iic.c iic2.c
    ../Mycode/MPU6050/: mpu6050.c
    ../Mycode/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
  group Library
    ../Library/src/: stm32f4xx_gpio.c stm32f4xx_rcc.c misc.c stm32f4xx_exti.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_adc.c stm32f4xx_dma.c stm32f4xx_pwr.c stm32f4xx_rtc.c
  group FreeRTOS_src
    ../FreeRTOS/src/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS_port
    ../FreeRTOS/port/MemMang/: heap_4.c
    ../FreeRTOS/port/RVDS/ARM_CM4F/: port.c
